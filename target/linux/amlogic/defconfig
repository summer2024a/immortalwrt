## target/linux/amlogic/image/Config.in
```kconfig
config AMLOGIC_SD_BOOT_PARTSIZE
	int "Boot (SD Card) filesystem partition size (in MB)"
	depends on TARGET_amlogic
	default 20
```
